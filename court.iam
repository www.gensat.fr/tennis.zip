# Autodesk Inventor assembly: court
## iProperties
Created: 2008-01
Part Number: court
Document SubType Name: Assembly
Designer: gjp
Author: gjp
