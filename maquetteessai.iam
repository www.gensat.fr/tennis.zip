# Autodesk Inventor assembly: maquetteessai
## iProperties
Created: 2008-01
Part Number: maquetteessai
Document SubType Name: Assembly
Designer: gjp
Author: gjp
