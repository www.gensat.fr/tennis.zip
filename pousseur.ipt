# Autodesk Inventor part: pousseur
## iProperties
Created: 2008-01
Part Number: pousseur
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Extrusion1
