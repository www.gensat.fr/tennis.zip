# Autodesk Inventor part: plateau
## iProperties
Created: 2008-01
Part Number: plateau
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Extrusion1
