# Autodesk Inventor part: filet
## iProperties
Created: 2008-01
Part Number: filet
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Extrusion1
