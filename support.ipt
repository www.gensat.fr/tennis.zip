# Autodesk Inventor part: support
## iProperties
Created: 2008-01
Part Number: support
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Extrusion1
