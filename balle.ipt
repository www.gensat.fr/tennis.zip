# Autodesk Inventor part: bille
## iProperties
Created: 2008-01
Part Number: bille
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Révolution1 [Revolution]
