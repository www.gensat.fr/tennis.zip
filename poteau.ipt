# Autodesk Inventor part: poteau
## iProperties
Created: 2008-01
Part Number: poteau
Document SubType Name: Modeling
Designer: gjp
Author: gjp
## Feature names
1. Extrusion1
2. Chanfrein1 [Chamfer]
